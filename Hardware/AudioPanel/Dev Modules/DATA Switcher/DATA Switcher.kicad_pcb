# Repository twfth9/Kenwood-Handset-Switch-PCB (continued)

## KiCad design Hardware/AudioPanel/Dev Modules/DATA Switcher/DATA Switcher.kicad_pcb (continued)

Parts:
C201, C207, C209, C216, C217: 4u7; CP_EIA-3216-18_Kemet-A; not fitted
C202, C210, C215: 4u7; Worthington_C_0402
C203, C204, C211, C212: 100p; Worthington_C_0402
C205, C213, C219, C220, C221: 100nF; Worthington_C_0402
C206, C208, C222, C223: 22uF; Worthington_C_0603
C214, C218: 1nF; Worthington_C_0402
D201, D202, D204, D205, D207: SD05; D_SOD-323
D203, D206: MBR0520; D_SOD-123; not fitted
F201: 0ZCJ0010FF2E; Fuse_1206_3216Metric
J201: Kenwood DATA; Connector_Mini-DIN_Female_6Pin_2rows
JP201, JP202, JP203, JP204, JP205, JP206: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R202, R211, R216, R223: 2.2k; Worthington_R_0402
R203, R212: 0; Worthington_R_0402
R204, R213, R220: 100k; Worthington_R_0402
R205, R210, R219: 5k; Worthington_R_0402
R206, R209, R222: 10k; Worthington_R_0402
R207, R208: 4k7; Worthington_R_0402
R214: 10k; Worthington_R_0402; not fitted
R215, R221: 15k; Worthington_R_0402; not fitted
R217, R218: 1k; Worthington_R_0402
TP201, TP202, TP203, TP204, TP205, TP206, TP208, TP209, TP210, TP211, TP212, TP213, TP214: TestPoint_Flag; KEYSTONE_5017
U107: 74HC4066BQ; QFN_104BQX_NEX
U201, U202: TLV2372; SOIC-8_3.9x4.9mm_P1.27mm
U203: SN74LVC1G14DCKR; SOT-353_SC-70-5

Connections:
/480_DATA.RATE: U107.12, U203.2; also elsewhere on the board
/480_DATA.RX: R214.2, TP201.1, U107.2, U107.10; also elsewhere on the board
/480_DATA.SQCIN: C219.1, D206.1 (K), R223.2; also elsewhere on the board
/480_DATA.TX: R218.2, TP213.1; also elsewhere on the board
/480_DATA.~PTT: C213.1, D203.1 (K), R216.2; also elsewhere on the board
/710_DATA.RATE: U107.5; also elsewhere on the board
/710_DATA.RX: U107.3, U107.9; also elsewhere on the board
/+5V_480_PORT: C220.1, C221.1, C222.1, C223.1, R207.1, R215.1, R221.1, U201.8 (V+), U202.8 (V+), U203.5 (VCC); also elsewhere on the board
/TS-480 Data Port Protection & Pre-Amp/AUDIO_TO_RADIO_T: C215.1, C216.1, D205.2 (A2), JP205.2 (B)
/TS-480 Data Port Protection & Pre-Amp/DATA_GND: J201.2, J201.7, JP206.2 (B), TP209.1
/TS-480 Data Port Protection & Pre-Amp/DATA_PKD: J201.1, JP205.1 (A), TP211.1
/TS-480 Data Port Protection & Pre-Amp/DATA_PKS: J201.3, JP203.1 (A), TP210.1
/TS-480 Data Port Protection & Pre-Amp/DATA_PR1: J201.5, JP201.1 (A), TP205.1
/TS-480 Data Port Protection & Pre-Amp/DATA_PR9: J201.4, JP204.2 (B), TP202.1
/TS-480 Data Port Protection & Pre-Amp/DATA_SQC: J201.6, JP202.2 (B), TP214.1
/TS-480 Data Port Protection & Pre-Amp/GND_FROM_RADIO: C203.2, C204.2, C211.2, C212.2, C213.2, C219.2, D201.1 (A1), D202.1 (A1), D204.1 (A1), D205.1 (A1), D207.1 (A1), F201.1, JP206.1 (A), R204.2, R213.2, R220.1
/TS-480 Data Port Protection & Pre-Amp/PTT_TO_RADIO_T: D204.2 (A2), JP203.2 (B), R216.1
/TS-480 Data Port Protection & Pre-Amp/RXFILTERED_FROM_RADIO_T: C209.1, C210.1, JP201.2 (B)
/TS-480 Data Port Protection & Pre-Amp/RXRAW_FROM_RADIO_T: C201.1, C202.1, JP204.1 (A)
/TS-480 Data Port Protection & Pre-Amp/SQUELCH_FROM_RADIO_T: D207.2 (A2), JP202.1 (A), R223.1
GND: C205.2, C206.2, C207.2, C208.2, C218.1, C220.2, C221.2, C222.2, C223.2, F201.2, R208.2, R214.1, R222.1, U201.4 (V-), U202.4 (V-), U203.3 (GND); also elsewhere on the board
unnamed: C204.1, R202.2, R203.1, TP203.1
unnamed: C212.1, R211.2, R212.1, TP206.1
unnamed: C214.1, R217.2, R218.1
unnamed: C214.2, C215.2, C217.1, R219.2, TP212.1, U202.1
unnamed: C216.2, C217.2, R220.2
unnamed: C201.2, C202.2, C203.1, D201.2 (A2), R202.1, R204.1
unnamed: C209.2, C210.2, C211.1, D202.2 (A2), R211.1, R213.1
unnamed: D203.2 (A), R215.2
unnamed: D206.2 (A), R221.2
unnamed: R205.1, TP204.1, U107.1, U201.1
unnamed: R210.1, TP208.1, U107.11, U201.7
unnamed 294: U107.8; also elsewhere on the board
unnamed 295: U107.4; also elsewhere on the board
unnamed 320: U107.6; also elsewhere on the board
unnamed: U107.13, U203.4
unnamed: R203.2, U201.3 (+)
unnamed: R205.2, R206.1, U201.2 (-)
unnamed: R212.2, U201.5 (+)
unnamed: R209.2, R210.2, U201.6 (-)
unnamed: C218.2, R217.1, U202.3 (+)
unnamed: R219.1, R222.2, U202.2 (-)
unnamed: C208.1, R207.2, R208.1, U202.5 (+)
unnamed: C205.1, C206.1, C207.1, R206.2, R209.1, U202.6 (-), U202.7

Parts of its further copies:
C301, C307, C309, C316, C317, C401, C407, C409, C416, C417, C501, C507, C509, C516, C517: 4u7; CP_EIA-3216-18_Kemet-A; not fitted
C302, C310, C315, C402, C410, C415, C502, C510, C515: 4u7; Worthington_C_0402
C303, C304, C311, C312, C403, C404, C411, C412, C503, C504, C511, C512: 100p; Worthington_C_0402
C305, C313, C319, C320, C321, C405, C413, C419, C420, C421, C505, C513, C519, C520, C521: 100nF; Worthington_C_0402
C306, C308, C322, C323, C406, C408, C422, C423, C506, C508, C522, C523: 22uF; Worthington_C_0603
C314, C318, C414, C418, C514, C518: 1nF; Worthington_C_0402
D301, D302, D304, D305, D307, D401, D402, D404, D405, D407, D501, D502, D504, D505, D507: SD05; D_SOD-323
D303, D306, D403, D406, D503, D506: MBR0520; D_SOD-123; not fitted
F301, F401, F501: 0ZCJ0010FF2E; Fuse_1206_3216Metric
J301, J401, J501: Kenwood DATA; Connector_Mini-DIN_Female_6Pin_2rows
JP301, JP302, JP303, JP304, JP305, JP306, JP401, JP402, JP403, JP404, JP405, JP406, JP501, JP502, JP503, JP504, JP505, JP506: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R302, R311, R316, R323, R402, R411, R416, R423, R502, R511, R516, R523: 2.2k; Worthington_R_0402
R303, R312, R403, R412, R503, R512: 0; Worthington_R_0402
R304, R313, R320, R404, R413, R420, R504, R513, R520: 100k; Worthington_R_0402
R305, R310, R319, R405, R410, R419, R505, R510, R519: 5k; Worthington_R_0402
R306, R309, R322, R406, R409, R422, R506, R509, R522: 10k; Worthington_R_0402
R307, R308, R407, R408, R507, R508: 4k7; Worthington_R_0402
R314, R414, R514: 10k; Worthington_R_0402; not fitted
R315, R321, R415, R421, R515, R521: 15k; Worthington_R_0402; not fitted
R317, R318, R417, R418, R517, R518: 1k; Worthington_R_0402
TP301, TP302, TP303, TP304, TP305, TP306, TP308, TP309, TP310, TP311, TP312, TP313, TP314, TP401, TP402, TP403, TP404, TP405, TP406, TP408, TP409, TP410, TP411, TP412, TP413, TP414, TP501, TP502, TP503, TP504, TP505, TP506, TP508, TP509, TP510, TP511, TP512, TP513, TP514: TestPoint_Flag; KEYSTONE_5017
U301, U302, U401, U402, U501, U502: TLV2372; SOIC-8_3.9x4.9mm_P1.27mm
U303, U403, U503: SN74LVC1G14DCKR; SOT-353_SC-70-5

Connections of its further copies:
/700_DATA.RATE: U403.2; also elsewhere on the board
/700_DATA.RX: R414.2, TP401.1; also elsewhere on the board
/700_DATA.SQCIN: C419.1, D406.1 (K), R423.2; also elsewhere on the board
/700_DATA.TX: R418.2, TP413.1; also elsewhere on the board
/700_DATA.~PTT: C413.1, D403.1 (K), R416.2; also elsewhere on the board
/710_DATA.RATE: U303.2; also elsewhere on the board
/710_DATA.RX: R314.2, TP301.1; also elsewhere on the board
/710_DATA.SQCIN: C319.1, D306.1 (K), R323.2; also elsewhere on the board
/710_DATA.TX: R318.2, TP313.1; also elsewhere on the board
/710_DATA.~PTT: C313.1, D303.1 (K), R316.2; also elsewhere on the board
/+5V_700_PORT: C420.1, C421.1, C422.1, C423.1, R407.1, R415.1, R421.1, U401.8 (V+), U402.8 (V+), U403.5 (VCC); also elsewhere on the board
/+5V_710_PORT: C320.1, C321.1, C322.1, C323.1, R307.1, R315.1, R321.1, U301.8 (V+), U302.8 (V+), U303.5 (VCC); also elsewhere on the board
/+5V_EXTRA_PORT: C520.1, C521.1, C522.1, C523.1, R507.1, R515.1, R521.1, U501.8 (V+), U502.8 (V+), U503.5 (VCC); also elsewhere on the board
/D-700 Data Port Protection & Pre-Amp/AUDIO_TO_RADIO_T: C415.1, C416.1, D405.2 (A2), JP405.2 (B)
/D-700 Data Port Protection & Pre-Amp/DATA_GND: J401.2, J401.7, JP406.2 (B), TP409.1
/D-700 Data Port Protection & Pre-Amp/DATA_PKD: J401.1, JP405.1 (A), TP411.1
/D-700 Data Port Protection & Pre-Amp/DATA_PKS: J401.3, JP403.1 (A), TP410.1
/D-700 Data Port Protection & Pre-Amp/DATA_PR1: J401.5, JP401.1 (A), TP405.1
/D-700 Data Port Protection & Pre-Amp/DATA_PR9: J401.4, JP404.2 (B), TP402.1
/D-700 Data Port Protection & Pre-Amp/DATA_SQC: J401.6, JP402.2 (B), TP414.1
/D-700 Data Port Protection & Pre-Amp/GND_FROM_RADIO: C403.2, C404.2, C411.2, C412.2, C413.2, C419.2, D401.1 (A1), D402.1 (A1), D404.1 (A1), D405.1 (A1), D407.1 (A1), F401.1, JP406.1 (A), R404.2, R413.2, R420.1
/D-700 Data Port Protection & Pre-Amp/PTT_TO_RADIO_T: D404.2 (A2), JP403.2 (B), R416.1
/D-700 Data Port Protection & Pre-Amp/RXFILTERED_FROM_RADIO_T: C409.1, C410.1, JP401.2 (B)
/D-700 Data Port Protection & Pre-Amp/RXRAW_FROM_RADIO_T: C401.1, C402.1, JP404.1 (A)
/D-700 Data Port Protection & Pre-Amp/SQUELCH_FROM_RADIO_T: D407.2 (A2), JP402.1 (A), R423.1
/D-710 Data Port Protection & Pre-Amp/AUDIO_TO_RADIO_T: C315.1, C316.1, D305.2 (A2), JP305.2 (B)
/D-710 Data Port Protection & Pre-Amp/DATA_GND: J301.2, J301.7, JP306.2 (B), TP309.1
/D-710 Data Port Protection & Pre-Amp/DATA_PKD: J301.1, JP305.1 (A), TP311.1
/D-710 Data Port Protection & Pre-Amp/DATA_PKS: J301.3, JP303.1 (A), TP310.1
/D-710 Data Port Protection & Pre-Amp/DATA_PR1: J301.5, JP301.1 (A), TP305.1
/D-710 Data Port Protection & Pre-Amp/DATA_PR9: J301.4, JP304.2 (B), TP302.1
/D-710 Data Port Protection & Pre-Amp/DATA_SQC: J301.6, JP302.2 (B), TP314.1
/D-710 Data Port Protection & Pre-Amp/GND_FROM_RADIO: C303.2, C304.2, C311.2, C312.2, C313.2, C319.2, D301.1 (A1), D302.1 (A1), D304.1 (A1), D305.1 (A1), D307.1 (A1), F301.1, JP306.1 (A), R304.2, R313.2, R320.1
/D-710 Data Port Protection & Pre-Amp/PTT_TO_RADIO_T: D304.2 (A2), JP303.2 (B), R316.1
/D-710 Data Port Protection & Pre-Amp/RXFILTERED_FROM_RADIO_T: C309.1, C310.1, JP301.2 (B)
/D-710 Data Port Protection & Pre-Amp/RXRAW_FROM_RADIO_T: C301.1, C302.1, JP304.1 (A)
/D-710 Data Port Protection & Pre-Amp/SQUELCH_FROM_RADIO_T: D307.2 (A2), JP302.1 (A), R323.1
/EXTRA Data Port Protection & Pre-Amp/AUDIO_TO_RADIO_T: C515.1, C516.1, D505.2 (A2), JP505.2 (B)
/EXTRA Data Port Protection & Pre-Amp/DATA_GND: J501.2, J501.7, JP506.2 (B), TP509.1
/EXTRA Data Port Protection & Pre-Amp/DATA_PKD: J501.1, JP505.1 (A), TP511.1
/EXTRA Data Port Protection & Pre-Amp/DATA_PKS: J501.3, JP503.1 (A), TP510.1
/EXTRA Data Port Protection & Pre-Amp/DATA_PR1: J501.5, JP501.1 (A), TP505.1
/EXTRA Data Port Protection & Pre-Amp/DATA_PR9: J501.4, JP504.2 (B), TP502.1
/EXTRA Data Port Protection & Pre-Amp/DATA_SQC: J501.6, JP502.2 (B), TP514.1
/EXTRA Data Port Protection & Pre-Amp/GND_FROM_RADIO: C503.2, C504.2, C511.2, C512.2, C513.2, C519.2, D501.1 (A1), D502.1 (A1), D504.1 (A1), D505.1 (A1), D507.1 (A1), F501.1, JP506.1 (A), R504.2, R513.2, R520.1
/EXTRA Data Port Protection & Pre-Amp/PTT_TO_RADIO_T: D504.2 (A2), JP503.2 (B), R516.1
/EXTRA Data Port Protection & Pre-Amp/RXFILTERED_FROM_RADIO_T: C509.1, C510.1, JP501.2 (B)
/EXTRA Data Port Protection & Pre-Amp/RXRAW_FROM_RADIO_T: C501.1, C502.1, JP504.1 (A)
/EXTRA Data Port Protection & Pre-Amp/SQUELCH_FROM_RADIO_T: D507.2 (A2), JP502.1 (A), R523.1
/EXTRA_DATA.RATE: U503.2; also elsewhere on the board
/EXTRA_DATA.RX: R514.2, TP501.1; also elsewhere on the board
/EXTRA_DATA.SQCIN: C519.1, D506.1 (K), R523.2; also elsewhere on the board
/EXTRA_DATA.TX: R518.2, TP513.1; also elsewhere on the board
/EXTRA_DATA.~PTT: C513.1, D503.1 (K), R516.2; also elsewhere on the board
GND: C305.2, C306.2, C307.2, C308.2, C318.1, C320.2, C321.2, C322.2, C323.2, C405.2, C406.2, C407.2, C408.2, C418.1, C420.2, C421.2, C422.2, C423.2, C505.2, C506.2, C507.2, C508.2, C518.1, C520.2, C521.2, C522.2, C523.2, F301.2, F401.2, F501.2, R308.2, R314.1, R322.1, R408.2, R414.1, R422.1, R508.2, R514.1, R522.1, U301.4 (V-), U302.4 (V-), U303.3 (GND), U401.4 (V-), U402.4 (V-), U403.3 (GND), U501.4 (V-), U502.4 (V-), U503.3 (GND); also elsewhere on the board
unnamed: C304.1, R302.2, R303.1, TP303.1
unnamed: C312.1, R311.2, R312.1, TP306.1
unnamed: C314.1, R317.2, R318.1
unnamed: C314.2, C315.2, C317.1, R319.2, TP312.1, U302.1
unnamed: C316.2, C317.2, R320.2
unnamed: C404.1, R402.2, R403.1, TP403.1
unnamed: C412.1, R411.2, R412.1, TP406.1
unnamed: C414.1, R417.2, R418.1
unnamed: C414.2, C415.2, C417.1, R419.2, TP412.1, U402.1
unnamed: C416.2, C417.2, R420.2
unnamed: C504.1, R502.2, R503.1, TP503.1
unnamed: C512.1, R511.2, R512.1, TP506.1
unnamed: C514.1, R517.2, R518.1
unnamed: C514.2, C515.2, C517.1, R519.2, TP512.1, U502.1
unnamed: C516.2, C517.2, R520.2
unnamed: C301.2, C302.2, C303.1, D301.2 (A2), R302.1, R304.1
unnamed: C309.2, C310.2, C311.1, D302.2 (A2), R311.1, R313.1
unnamed: D303.2 (A), R315.2
unnamed: D306.2 (A), R321.2
unnamed: C401.2, C402.2, C403.1, D401.2 (A2), R402.1, R404.1
unnamed: C409.2, C410.2, C411.1, D402.2 (A2), R411.1, R413.1
unnamed: D403.2 (A), R415.2
unnamed: D406.2 (A), R421.2
unnamed: C501.2, C502.2, C503.1, D501.2 (A2), R502.1, R504.1
unnamed: C509.2, C510.2, C511.1, D502.2 (A2), R511.1, R513.1
unnamed: D503.2 (A), R515.2
unnamed: D506.2 (A), R521.2
unnamed 294: R305.1, TP304.1, U301.1; also elsewhere on the board
unnamed 295: R310.1, TP308.1, U301.7; also elsewhere on the board
unnamed 296: R405.1, TP404.1, U401.1; also elsewhere on the board
unnamed 297: R410.1, TP408.1, U401.7; also elsewhere on the board
unnamed 298: R505.1, TP504.1, U501.1; also elsewhere on the board
unnamed 299: R510.1, TP508.1, U501.7; also elsewhere on the board
unnamed 320: U303.4; also elsewhere on the board
unnamed 322: U503.4; also elsewhere on the board
unnamed 323: U403.4; also elsewhere on the board
unnamed: R303.2, U301.3 (+)
unnamed: R305.2, R306.1, U301.2 (-)
unnamed: R312.2, U301.5 (+)
unnamed: R309.2, R310.2, U301.6 (-)
unnamed: C318.2, R317.1, U302.3 (+)
unnamed: R319.1, R322.2, U302.2 (-)
unnamed: C308.1, R307.2, R308.1, U302.5 (+)
unnamed: C305.1, C306.1, C307.1, R306.2, R309.1, U302.6 (-), U302.7
unnamed: R403.2, U401.3 (+)
unnamed: R405.2, R406.1, U401.2 (-)
unnamed: R412.2, U401.5 (+)
unnamed: R409.2, R410.2, U401.6 (-)
unnamed: C418.2, R417.1, U402.3 (+)
unnamed: R419.1, R422.2, U402.2 (-)
unnamed: C408.1, R407.2, R408.1, U402.5 (+)
unnamed: C405.1, C406.1, C407.1, R406.2, R409.1, U402.6 (-), U402.7
unnamed: R503.2, U501.3 (+)
unnamed: R505.2, R506.1, U501.2 (-)
unnamed: R512.2, U501.5 (+)
unnamed: R509.2, R510.2, U501.6 (-)
unnamed: C518.2, R517.1, U502.3 (+)
unnamed: R519.1, R522.2, U502.2 (-)
unnamed: C508.1, R507.2, R508.1, U502.5 (+)
unnamed: C505.1, C506.1, C507.1, R506.2, R509.1, U502.6 (-), U502.7

Notes on the sheet:
1200bps RX output (500mVp-p, 10kΩ)
DC Biased to +5V from Radio
Packet Standby Switch TNC uses this pin to inhibit the transceiver mic input while transmitting
Low-Pass 3dB: 15.9kHz
RX Audio Output Raw Output Level: 500mVp-p, 10kΩ Always output whether squelch is open or closed
Low-Pass 3dB: 723Hz (484μs)
DC Bias: +2.5V
Board should not need to amplify signal from/to radio, but provisions are here to amplify up to 2x to overcome losses from switching
TX data from external TNC to transceiver
Low-Pass 3dB: 723kHz
RX Output Through Deemphesis Filters Output Level: 500mVp-p, 10kΩ Always output whether squelch is open or closed
Ground for PKD
Separate OpAmp stages allow separate gain adjustment between 1200 and 9600 baud modes
9600bps RX output (500mVp-p, 10kΩ)
Pulled-Up to +5V by Radio
2nd Order Low-Pass & Buffer fc = 100kHz
May be overkill, but I had one opamp extra so ¯\_(ツ)_/¯
BPS Mode: 1200bps 9600bps Input: 40mVp-p 2Vp-p Deviation: 3±0.5kHz 2.2±0.5kHz Impedance: 10kΩ 10kΩ
Packet Data Input
SQL Control Voltage Out (+5V) Open Squelch (0V) Closed Squelch
Low-Pass filter & 1.5x gain (Max 2, Min 1) to overcome losses from switching

Parts:
C601, C602, C603, C604: 100nF; Worthington_C_0402
C605, C606, C607, C608: 22uF; Worthington_C_0603
D601, D602, D603, D604, D605, D606, D607, D608, D609, D610, D611, D612, D613, D614, D615, D616, D617, D618, D619, D620, D621, D622, D623, D624: Green; Worthington_LED_0603; DigiKey Part Number 732-5016-ND
RN601, RN602, RN605, RN606, RN607, RN609: 1k; RES_ARRAY_4RES_0804
U601: SN74LV165ARGYR; RGY16_2P55X2P05
U602, U603, U604: SN74LV595ARGYR; RGY16_2P55X2P05

Connections:
/4x4 Analog Crosspoint Switch/A1: U604.15 (QA); also elsewhere on the board
/4x4 Analog Crosspoint Switch/A2: U603.7 (QH); also elsewhere on the board
/4x4 Analog Crosspoint Switch/A3: U604.1 (QB); also elsewhere on the board
/4x4 Analog Crosspoint Switch/B0: U604.7 (QH); also elsewhere on the board
/4x4 Analog Crosspoint Switch/B2: U603.6 (QG); also elsewhere on the board
/4x4 Analog Crosspoint Switch/B3: U603.5 (QF); also elsewhere on the board
/4x4 Analog Crosspoint Switch/C0: U604.3 (QD); also elsewhere on the board
/4x4 Analog Crosspoint Switch/C1: U604.2 (QC); also elsewhere on the board
/4x4 Analog Crosspoint Switch/C3: U603.4 (QE); also elsewhere on the board
/4x4 Analog Crosspoint Switch/D0: U604.6 (QG); also elsewhere on the board
/4x4 Analog Crosspoint Switch/D1: U604.4 (QE); also elsewhere on the board
/4x4 Analog Crosspoint Switch/D2: U604.5 (QF); also elsewhere on the board
/480_DATA.RATE: D607.1 (K), D615.2 (A), U602.1 (QB); also elsewhere on the board
/480_DATA.SQCIN: U601.11 (A); also elsewhere on the board
/480_DATA.~PTT: D608.1 (K), D616.2 (A), U601.12 (B), U602.15 (QA); also elsewhere on the board
/480_RIGCTRL/~MUX: D606.1 (K), D614.2 (A), U602.2 (QC); also elsewhere on the board
/700_DATA.RATE: D601.1 (K), D609.2 (A), U602.7 (QH); also elsewhere on the board
/700_DATA.SQCIN: U601.3 (E); also elsewhere on the board
/700_DATA.~PTT: D602.1 (K), D610.2 (A), U601.4 (F), U602.6 (QG); also elsewhere on the board
/700_RIGCTRL/~MUX: D620.1 (K), D624.2 (A), U603.15 (QA); also elsewhere on the board
/710_DATA.RATE: D604.1 (K), D612.2 (A), U602.4 (QE); also elsewhere on the board
/710_DATA.SQCIN: U601.13 (C); also elsewhere on the board
/710_DATA.~PTT: D605.1 (K), D613.2 (A), U601.14 (D), U602.3 (QD); also elsewhere on the board
/710_RIGCTRL/~MUX: D603.1 (K), D611.2 (A), U602.5 (QF); also elsewhere on the board
/+5V_SIPO_PISO: C601.1, C602.1, C603.1, C604.1, C605.1, C606.1, C607.1, C608.1, RN601.5, RN601.6, RN601.7 (5), RN601.8, RN602.5, RN602.6, RN602.7 (5), RN602.8, RN605.5, RN605.6, RN605.7 (5), RN605.8, U601.16 (VCC), U602.16 (VCC), U603.16 (VCC), U604.16 (VCC); also elsewhere on the board
/EXTRA_DATA.RATE: D618.1 (K), D622.2 (A), U603.2 (QC); also elsewhere on the board
/EXTRA_DATA.SQCIN: U601.5 (G); also elsewhere on the board
/EXTRA_DATA.~PTT: D619.1 (K), D623.2 (A), U601.6 (H), U603.1 (QB); also elsewhere on the board
/EXTRA_RIGCTRL/~MUX: D617.1 (K), D621.2 (A), U603.3 (QD); also elsewhere on the board
/SAMD_LATCH: U602.12 (RCLK), U603.12 (RCLK), U604.12 (RCLK); also elsewhere on the board
/SAMD_LOAD: U601.1 (SH/~LD); also elsewhere on the board
/SAMD_MISO: U601.9 (QH); also elsewhere on the board
/SAMD_MOSI: U602.14 (SER); also elsewhere on the board
/SAMD_SCLK: U601.2 (CLK), U602.11 (SRCLK), U603.11 (SRCLK), U604.11 (SRCLK); also elsewhere on the board
/SAMD_~OE: U602.13 (~OE), U603.13 (~OE), U604.13 (~OE); also elsewhere on the board
/SERIAL_OUT_DEBUG: U604.9 (QH'); also elsewhere on the board
/SERIAL_~CLEAR_DEBUG: U602.10 (~SRCLR), U603.10 (~SRCLR), U604.10 (~SRCLR); also elsewhere on the board
/SIPO 24bit & PISO 8bit Shift Registers/595_A-B: U602.9 (QH'), U603.14 (SER)
/SIPO 24bit & PISO 8bit Shift Registers/595_B-C: U603.9 (QH'), U604.14 (SER)
/SIPO 24bit & PISO 8bit Shift Registers/PISO_~INPUT_EN: U601.15 (~CE)
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, RN606.1 (4), RN606.2, RN606.3, RN606.4, RN607.1 (4), RN607.2, RN607.3, RN607.4, RN609.1 (4), RN609.2, RN609.3, RN609.4, U601.8 (GND), U601.10 (SER), U601.17 (GND), U602.8 (GND), U602.17 (GND), U603.8 (GND), U603.17 (GND), U604.8 (GND), U604.17 (GND); also elsewhere on the board
unnamed: D601.2 (A), RN601.4
unnamed: D602.2 (A), RN601.3
unnamed: D603.2 (A), RN601.2
unnamed: D604.2 (A), RN601.1 (4)
unnamed: D605.2 (A), RN602.4
unnamed: D606.2 (A), RN602.3
unnamed: D607.2 (A), RN602.2
unnamed: D608.2 (A), RN602.1 (4)
unnamed: D609.1 (K), RN606.5
unnamed: D610.1 (K), RN606.6
unnamed: D611.1 (K), RN606.7 (5)
unnamed: D612.1 (K), RN606.8
unnamed: D613.1 (K), RN607.5
unnamed: D614.1 (K), RN607.6
unnamed: D615.1 (K), RN607.7 (5)
unnamed: D616.1 (K), RN607.8
unnamed: D617.2 (A), RN605.4
unnamed: D618.2 (A), RN605.3
unnamed: D619.2 (A), RN605.2
unnamed: D620.2 (A), RN605.1 (4)
unnamed: D621.1 (K), RN609.5
unnamed: D622.1 (K), RN609.6
unnamed: D623.1 (K), RN609.7 (5)
unnamed: D624.1 (K), RN609.8

Notes on the sheet:
Serial-In/Parallel-Out
595-B
595-A
595-C
165-A
